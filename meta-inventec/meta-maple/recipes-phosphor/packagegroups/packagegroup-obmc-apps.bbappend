RDEPENDS_${PN}-extras_append_maple = "phosphor-webui phosphor-image-signing"
